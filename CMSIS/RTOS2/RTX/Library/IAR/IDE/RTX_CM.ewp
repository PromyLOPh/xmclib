# IAR project RTX_CM.ewp, settings and files
configuration CM0 (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __ARM_ARCH_6M__; CMSIS_device_header="ARMCM0.h"
  ICCARM.CCIncludePath2: ..\..\..\Config; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMCM0\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: RTX_CM.out
configuration CM3 (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; __ARM_ARCH_7M__; CMSIS_device_header="ARMCM3.h"
  ICCARM.CCIncludePath2: ..\..\..\Config; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMCM3\Include
configuration CM4F (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; __ARM_ARCH_7EM__; CMSIS_device_header="ARMCM4_FP.h"
  ICCARM.CCIncludePath2: ..\..\..\Config; ..\..\..\Include; ..\..\..\..\Include; ..\..\..\..\..\Core\Include; $PROJ_DIR$; ..\..\..\..\..\..\Device\ARM\ARMCM4\Include
  group Core
    ../../../Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group Handlers
    ../../../Source/IAR/: irq_cm0.s irq_cm3.s irq_cm4f.s
