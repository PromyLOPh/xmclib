# IAR project generichid.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4500-F100x1024 Infineon XMC4500-F100x1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4500_F100x1024
  ICCARM.CCIncludePath2: ..\.; ..\..\..\..\..\XMClib\inc; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\CMSIS\Infineon\XMC4500_series\Include; ..\..\..\..\.
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: virtualserial.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Descriptors.c GenericHID.c main.c
  group Libraries/CMSIS
    ../../../../../CMSIS/Infineon/XMC4500_series/Source/IAR/: startup_XMC4500.s
    ../../../../../CMSIS/Infineon/XMC4500_series/Source/: system_XMC4500.c
  group Libraries/USB
    ../../../../USB/Core/: ConfigDescriptors.c Events.c USBTask.c
    ../../../../USB/Core/XMC4000/: Endpoint_XMC4000.c EndpointStream_XMC4000.c USBController_XMC4000.c
    ../../../../USB/Class/Device/: HIDClassDevice.c
  group Libraries/XMClib
    ../../../../../XMClib/src/: xmc4_gpio.c xmc4_scu.c xmc_common.c xmc_gpio.c xmc_usbd.c
