# IAR project winusb.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4500-F144x1024 Infineon XMC4500-F144x1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4500_F144x1024
  ICCARM.CCIncludePath2: ..\.; ..\..\..\..\..\XMClib\inc; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\CMSIS\Infineon\XMC4500_series\Include; ..\..\..\..\.
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: winusb.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Descriptors.c main.c WinUSB.c
  group Libraries/CMSIS
    ../../../../../CMSIS/Infineon/XMC4500_series/Source/IAR/: startup_XMC4500.s
    ../../../../../CMSIS/Infineon/XMC4500_series/Source/: system_XMC4500.c
  group Libraries/USB
    ../../../../USB/Class/Device/: CDCClassDevice.c
    ../../../../USB/Core/: ConfigDescriptors.c Events.c USBTask.c
    ../../../../USB/Core/XMC4000/: Endpoint_XMC4000.c EndpointStream_XMC4000.c USBController_XMC4000.c
  group Libraries/XMClib
    ../../../../../XMClib/src/: xmc4_gpio.c xmc4_scu.c xmc_common.c xmc_gpio.c xmc_i2c.c xmc_usbd.c xmc_usic.c xmc_vadc.c
