# Keil uVision project ccu4_timer.uvprojx, settings and files
target ccu4_timer (5060020::V5.06 (build 20)::ARMCC)
  device: XMC1402-F064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.2.0
  cpu: IROM(0x10001000,0x32000) IRAM(0x20000000,0x3FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ccu4_timer
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 4.2.0, Device:Startup 1.3.0, Device:XMClib:CCU4 2.1.0, Device:XMClib:SCU 2.1.0
