# Keil uVision project blinky.uvprojx, settings and files
target XMC1400 BootKit (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: XMC1404-Q064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.5.1
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x32000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Blinky;..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\include;..\..\..\..\..\..\ThirdPartyLibraries\FreeRTOS\Source\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Files
    ../: main.c
  group FreeRTOS
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../../../ThirdPartyLibraries/FreeRTOS/Source/portable/MemMang/: heap_3.c
  group Documentation
    ../: Readme.txt
software components: CMSIS:CORE 5.0.1, Device:Startup 2.0.0, Device:XMClib:GPIO 2.1.8
