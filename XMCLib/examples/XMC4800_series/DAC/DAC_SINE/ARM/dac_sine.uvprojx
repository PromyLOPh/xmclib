# Keil uVision project dac_sine.uvprojx, settings and files
target dac_sine (5060020::V5.06 (build 20)::ARMCC)
  device: XMC4800-E196x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0x1FFC0) IRAM2(0x1FFEE000,0x12000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dac_sine
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1ffc0
  memory RVCT10: RAM 0x1ffee000 size 0x12000
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
software components: CMSIS:CORE 4.2.0, Device:Startup 1.5.0, Device:XMClib:DAC 2.1.2, Device:XMClib:SCU 2.1.2
