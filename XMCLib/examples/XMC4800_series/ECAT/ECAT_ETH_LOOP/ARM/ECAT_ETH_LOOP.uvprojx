# Keil uVision project ECAT_ETH_LOOP.uvprojx, settings and files
target XMC4800 Relax Kit (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: XMC4800-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.8.0
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECAT_ETH_LOOP
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XMC_ETH_PHY_KSZ8081RNB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group Source Files
    ../: main.c
  group Documentation
    ../: Readme.txt
software components: CMSIS:CORE 5.0.1, Device:Startup 2.1.0, Device:XMClib:ECAT 2.1.12, Device:XMClib:ETH_MAC 2.1.12, Device:XMClib:ETH_PHY 2.1.12, Device:XMClib:GPIO 2.1.12, Device:XMClib:SCU 2.1.12
