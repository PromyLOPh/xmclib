# Keil uVision project httpserver_netconn.uvprojx, settings and files
target httpserver_netconn (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: XMC4800-F144x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.5.2
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: httpserver_netconn
  c flags: Optim=2 wLevel=2
  c include: ..\lwip\include;..\lwip\include\ipv4;..\lwip\port\cmsis-rtos\include;..\lwip\port\cmsis-rtos\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ../: main.c xmc_eth_phy_ksz8081rnl.c
    ../httpserver_netconn/: httpserver-netconn.c
  group Doc
    ../: README.txt
  group lwip
    ../lwip/netif/: etharp.c slipif.c
    ../lwip/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
    ../lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../lwip/port/cmsis-rtos/: sys_arch.c
    ../lwip/port/cmsis-rtos/netif/: ethernetif.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 1.5.0, Device:XMClib:ETH_MAC 2.1.4, Device:XMClib:GPIO 2.1.4, Device:XMClib:SCU 2.1.4
