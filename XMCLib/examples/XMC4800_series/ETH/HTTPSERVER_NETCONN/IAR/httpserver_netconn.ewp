# IAR project httpserver_netconn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4700-F144x2048 Infineon XMC4700-F144x2048
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4700_F144x2048; __CORTEX_M4F; __FPU_PRESENT; __CMSIS_RTOS
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\XMClib\inc; ..\..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\..\CMSIS\Infineon\XMC4700_series\Include; ..\cmsis_rtos_rtx\INC; ..\cmsis_rtos_rtx\SRC; ..\lwip\include; ..\lwip\include\ipv4; ..\lwip\port\cmsis-rtos\include; ..\lwip\port\cmsis-rtos\netif
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: httpserver_netconn.srec
  ILINK.IlinkOutputFile: httpserver_netconn.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c xmc_eth_phy_ksz8081rnl.c
  group cmsis_rtos_rtx
    ../cmsis_rtos_rtx/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../cmsis_rtos_rtx/SRC/IAR/: HAL_CM4.s SVC_Table.s
    ../cmsis_rtos_rtx/: RTX_Conf_CM.c
  group httpserver_netconn
    ../httpserver_netconn/: httpserver-netconn.c
  group Libraries/CMSIS
    ../../../../../../CMSIS/Infineon/XMC4700_series/Source/IAR/: startup_XMC4700.s
    ../../../../../../CMSIS/Infineon/XMC4700_series/Source/: system_XMC4700.c
  group Libraries/XMClib
    ../../../../../src/: xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_ebu.c xmc_eru.c xmc_eth_mac.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_i2c.c xmc_ledts.c xmc_posif.c xmc_rtc.c xmc_sdmmc.c xmc_spi.c xmc_uart.c xmc_usbd.c xmc_usic.c xmc_vadc.c xmc_wdt.c
  group lwip/api
    ../lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip/core/ipv4
    ../lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip/core/snmp
    ../lwip/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwip/netif
    ../lwip/netif/: etharp.c slipif.c
  group lwip/netif/ppp
    ../lwip/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group lwip/port/cmsis-rtos
    ../lwip/port/cmsis-rtos/: sys_arch.c
  group lwip/port/cmsis-rtos/netif
    ../lwip/port/cmsis-rtos/netif/: ethernetif.c
